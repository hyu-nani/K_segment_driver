<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\segment_stm32f030_test.ewp</path>
  </project>
  <batchBuild />
</workspace>

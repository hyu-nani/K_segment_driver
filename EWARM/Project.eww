<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\K_segment_driver.ewp</path>
  </project>
  <batchBuild />
</workspace>

<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F030K6T6.ewp</path>
  </project>
  <batchBuild />
</workspace>
